options:
  parameters:
    generate_options: qt_gui
    id: ldFMmodulate
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: add_wSNR
  id: variable
  parameters:
    comment: |-
      0 = Add white lines to the VBI to calculate wSNR
      1 = Leave source vdieo lines in tact

      NOTE: Decode will be off if there are no white lines
      in the VBI, so if your source doesn't have it, then select
      to add white lines.
    value: '0'
  states: {}
- name: line_length
  id: variable
  parameters:
    comment: |-
      910 NTSC
      1135 PAL
      (currently only NTSC supported)
    value: '910'
  states: {}
- name: lines_per_frame
  id: variable
  parameters:
    comment: |-
      525 NTSC
      625 PAL
    value: '525'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 40e6
  states: {}
- name: source_samp_rate
  id: variable
  parameters:
    value: '14318181'
  states: {}
- name: analog_const_source_x_0_0
  id: analog_const_source_x
  parameters:
    const: '32768'
    type: float
  states: {}
- name: analog_const_source_x_0_0_0
  id: analog_const_source_x
  parameters:
    const: '32768'
    type: float
  states: {}
- name: analog_const_source_x_1
  id: analog_const_source_x
  parameters:
    const: '32768'
    type: float
  states: {}
- name: analog_const_source_x_1_0
  id: analog_const_source_x
  parameters:
    const: '32768'
    type: float
  states: {}
- name: analog_const_source_x_4
  id: analog_const_source_x
  parameters:
    comment: '90'
    const: '.56'
    type: float
  states: {}
- name: analog_fm_preemph_0
  id: analog_fm_preemph
  parameters:
    comment: '15e-8'
    fh: '-1'
    samp_rate: 40e6
    tau: '15e-8'
  states: {}
- name: analog_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    comment: |-
      .466 with freq shift 9.7m worked
      .15 with 8.55 shift worked much better!
      .177 and 8.66 shift worked and close
    sensitivity: '.196'
  states: {}
- name: analog_rail_ff_0
  id: analog_rail_ff
  parameters:
    hi: '1'
    lo: '-1'
  states: {}
- name: analog_rail_ff_1
  id: analog_rail_ff
  parameters:
    hi: '1'
    lo: '-1'
  states: {}
- name: analog_rail_ff_1_0
  id: analog_rail_ff
  parameters:
    hi: '1'
    lo: '-1'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    comment: maybe better without these
    decim: '1'
    gain: '1'
    high_cutoff_freq: 14e6
    low_cutoff_freq: 3.5e6
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 100e3
    win: window.WIN_HAMMING
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_0_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_0_0_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_deinterleave_0_0
  id: blocks_deinterleave
  parameters:
    type: float
  states: {}
- name: blocks_deinterleave_0_0_0
  id: blocks_deinterleave
  parameters:
    type: float
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '175'
    type: float
  states: {}
- name: blocks_divide_xx_0_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_divide_xx_0_0_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    comment: .s16 extension
    file: /tmp/TESTldFMfromYCwSNR.s16
    type: short
  states: {}
- name: blocks_file_source_0_0_0
  id: blocks_file_source
  parameters:
    file: /home/tandersn/CAPTURES/encoder/PADiceagethx.tbc
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_file_source_0_0_0_0
  id: blocks_file_source
  parameters:
    file: /home/tandersn/CAPTURES/encoder/PADiceagethx_chroma.tbc
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    scale: '32767'
  states: {}
- name: blocks_freqshift_cc_0
  id: blocks_freqshift_cc
  parameters:
    freq: 8.67e6
    sample_rate: samp_rate
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '.85'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '256'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '256'
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
    vlen: line_length
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: add_wSNR
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_stream_demux_0
  id: blocks_stream_demux
  parameters:
    lengths: (lines_per_frame, 1)
    type: float
    vlen: line_length
  states: {}
- name: blocks_stream_demux_0_0
  id: blocks_stream_demux
  parameters:
    lengths: (150,760)
    type: float
  states: {}
- name: blocks_stream_demux_0_1
  id: blocks_stream_demux
  parameters:
    lengths: (9, 9, 245)
    num_outputs: '3'
    type: float
    vlen: line_length
  states: {}
- name: blocks_stream_mux_0_0
  id: blocks_stream_mux
  parameters:
    lengths: (150,760 )
    type: float
  states: {}
- name: blocks_stream_mux_0_1
  id: blocks_stream_mux
  parameters:
    lengths: (9 , 9,  245)
    num_inputs: '3'
    type: float
    vlen: '910'
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: line_length
    type: float
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: line_length
    type: float
  states: {}
- name: blocks_stream_to_vector_0_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: line_length
    type: float
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_0_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_uchar_to_float_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_0_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: line_length
    type: float
  states: {}
- name: blocks_vector_to_stream_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: line_length
    type: float
  states: {}
- name: blocks_vector_to_stream_0_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: line_length
    type: float
  states: {}
- name: filter_fft_low_pass_filter_0
  id: filter_fft_low_pass_filter
  parameters:
    comment: maybe better without these
    cutoff_freq: 5.2e6
    decim: '1'
    gain: '1'
    nthreads: '5'
    samp_rate: samp_rate
    type: fff
    width: 1e5
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 5.2e6
    decim: '1'
    gain: '.5'
    samp_rate: source_samp_rate
    type: fir_filter_fff
    width: 100e3
    win: window.WIN_HAMMING
  states: {}
- name: mmse_resampler_xx_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: source_samp_rate/samp_rate
    type: float
  states: {}
- name: note_0
  id: note
  parameters:
    comment: ffmpeg -i thx.avi -an -vf "scale=758:480,pad=758:486:0:3" -vcodec rawvideo -pix_fmt yuv444p16 -f rawvideo - | ld-chroma-encoder -p yuv -f NTSC - PADiceagethxY.tbc PADiceagethxC.tbc
    note: Example command from a DVD source
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    size: '1000000'
    srate: source_samp_rate
    type: float
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: Y
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: '2'
  states: {}
- name: virtual_sink_0_1
  id: virtual_sink
  parameters:
    stream_id: C
  states: {}
- name: virtual_sink_0_1_0
  id: virtual_sink
  parameters:
    stream_id: '1'
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: '1'
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: '2'
  states: {}
- name: virtual_source_0_1
  id: virtual_source
  parameters:
    stream_id: Y
  states: {}
- name: virtual_source_0_2
  id: virtual_source
  parameters:
    stream_id: C
  states: {}

connections:
- [analog_const_source_x_0_0, '0', blocks_divide_xx_0_0, '1']
- [analog_const_source_x_0_0_0, '0', blocks_divide_xx_0_0_0, '1']
- [analog_const_source_x_1, '0', blocks_sub_xx_0, '1']
- [analog_const_source_x_1_0, '0', blocks_sub_xx_0_0, '1']
- [analog_const_source_x_4, '0', blocks_stream_mux_0_0, '1']
- [analog_fm_preemph_0, '0', virtual_sink_0_0, '0']
- [analog_frequency_modulator_fc_0, '0', blocks_freqshift_cc_0, '0']
- [analog_rail_ff_0, '0', blocks_float_to_short_0, '0']
- [analog_rail_ff_0, '0', qtgui_freq_sink_x_0, '0']
- [analog_rail_ff_0, '0', qtgui_time_sink_x_0, '0']
- [analog_rail_ff_1, '0', virtual_sink_0, '0']
- [analog_rail_ff_1_0, '0', virtual_sink_0_1, '0']
- [band_pass_filter_0, '0', blocks_complex_to_real_0, '0']
- [blocks_add_xx_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_add_xx_0, '0', virtual_sink_0_1_0, '0']
- [blocks_add_xx_0_0, '0', blocks_sub_xx_0, '0']
- [blocks_add_xx_0_0_0, '0', blocks_sub_xx_0_0, '0']
- [blocks_complex_to_real_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_deinterleave_0_0, '0', blocks_add_xx_0_0, '0']
- [blocks_deinterleave_0_0, '1', blocks_multiply_const_vxx_0_0, '0']
- [blocks_deinterleave_0_0_0, '0', blocks_add_xx_0_0_0, '0']
- [blocks_deinterleave_0_0_0, '1', blocks_multiply_const_vxx_0_0_0, '0']
- [blocks_delay_0, '0', blocks_add_xx_0, '0']
- [blocks_divide_xx_0_0, '0', analog_rail_ff_1, '0']
- [blocks_divide_xx_0_0_0, '0', analog_rail_ff_1_0, '0']
- [blocks_file_source_0_0_0, '0', blocks_uchar_to_float_0_0, '0']
- [blocks_file_source_0_0_0_0, '0', blocks_uchar_to_float_0_0_0, '0']
- [blocks_float_to_short_0, '0', blocks_file_sink_0, '0']
- [blocks_freqshift_cc_0, '0', band_pass_filter_0, '0']
- [blocks_multiply_const_vxx_0, '0', analog_rail_ff_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_add_xx_0_0, '1']
- [blocks_multiply_const_vxx_0_0_0, '0', blocks_add_xx_0_0_0, '1']
- [blocks_selector_0, '0', blocks_delay_0, '0']
- [blocks_stream_demux_0, '0', blocks_vector_to_stream_0, '0']
- [blocks_stream_demux_0, '1', blocks_null_sink_0, '0']
- [blocks_stream_demux_0_0, '0', blocks_stream_mux_0_0, '0']
- [blocks_stream_demux_0_0, '1', blocks_null_sink_0_0, '0']
- [blocks_stream_demux_0_1, '0', blocks_stream_mux_0_1, '0']
- [blocks_stream_demux_0_1, '1', blocks_vector_to_stream_0_0, '0']
- [blocks_stream_demux_0_1, '2', blocks_stream_mux_0_1, '2']
- [blocks_stream_mux_0_0, '0', blocks_stream_to_vector_0_0_0, '0']
- [blocks_stream_mux_0_1, '0', blocks_vector_to_stream_0_0_0, '0']
- [blocks_stream_to_vector_0, '0', blocks_stream_demux_0, '0']
- [blocks_stream_to_vector_0_0, '0', blocks_stream_demux_0_1, '0']
- [blocks_stream_to_vector_0_0_0, '0', blocks_stream_mux_0_1, '1']
- [blocks_sub_xx_0, '0', blocks_divide_xx_0_0, '0']
- [blocks_sub_xx_0_0, '0', blocks_divide_xx_0_0_0, '0']
- [blocks_throttle_0_0, '0', filter_fft_low_pass_filter_0, '0']
- [blocks_uchar_to_float_0_0, '0', blocks_deinterleave_0_0, '0']
- [blocks_uchar_to_float_0_0_0, '0', blocks_deinterleave_0_0_0, '0']
- [blocks_vector_to_stream_0, '0', mmse_resampler_xx_0, '0']
- [blocks_vector_to_stream_0_0, '0', blocks_stream_demux_0_0, '0']
- [blocks_vector_to_stream_0_0_0, '0', blocks_selector_0, '0']
- [filter_fft_low_pass_filter_0, '0', analog_fm_preemph_0, '0']
- [low_pass_filter_0, '0', blocks_add_xx_0, '1']
- [mmse_resampler_xx_0, '0', blocks_throttle_0_0, '0']
- [virtual_source_0, '0', blocks_stream_to_vector_0, '0']
- [virtual_source_0_0, '0', analog_frequency_modulator_fc_0, '0']
- [virtual_source_0_1, '0', blocks_selector_0, '1']
- [virtual_source_0_1, '0', blocks_stream_to_vector_0_0, '0']
- [virtual_source_0_2, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.0
