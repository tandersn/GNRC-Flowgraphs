options:
  parameters:
    generate_options: qt_gui
    id: ishortcapture
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: NTSC
  id: variable
  parameters:
    value: '1500000'
  states: {}
- name: PAL
  id: variable
  parameters:
    value: '1600000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1.024e6
  states: {}
- name: system
  id: variable
  parameters:
    value: NTSC
  states: {}
- name: variable_qtgui_label_0
  id: variable_qtgui_label
  parameters:
    label: 'Center FREQ:'
    type: int
    value: system
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /VHS/captures/hifi/ishort_hifi.complex16
    type: short
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    type: short
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    agc: '1'
    center_freq: system
    dev_args: dev=0,direct_samp=2,biastee=true
    gain: '10'
    samp_rate: 1.024e6
    type: sc16
  states: {}

connections:
- [blocks_vector_to_stream_0, '0', blocks_file_sink_0, '0']
- [soapy_rtlsdr_source_0, '0', blocks_vector_to_stream_0, '0']

metadata:
  file_format: 1
