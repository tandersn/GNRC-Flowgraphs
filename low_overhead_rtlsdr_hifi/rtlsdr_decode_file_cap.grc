options:
  parameters:
    generate_options: qt_gui
    id: rtlsdr_decode_ishortcap
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: NTSC
  id: variable
  parameters:
    value: '1500000'
  states: {}
- name: PAL
  id: variable
  parameters:
    value: '1600000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1.024e6
  states: {}
- name: system
  id: variable
  parameters:
    value: NTSC
  states: {}
- name: variable_qtgui_label
  id: variable_qtgui_label
  parameters:
    type: int
    value: system
  states: {}
- name: analog_rail_ff_1
  id: analog_rail_ff
  parameters:
    hi: '255'
    lo: '0'
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    comment: output file is 8.192msps  use hifi decode  -f 8.192
    file: /VHS/captures/hifi/ishort8192ksps.u8
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /VHS/captures/hifi/ishort_hifi.s16
    repeat: 'False'
    type: short
  states: {}
- name: blocks_float_to_uchar_0
  id: blocks_float_to_uchar
  parameters: {}
  states: {}
- name: blocks_freqshift_cc_0
  id: blocks_freqshift_cc
  parameters:
    freq: 1.5e6
    sample_rate: 8.192e6
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: '14000'
    vector_input: 'False'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '128'
    type: float
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate*8
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '8'
    type: ccc
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: RF
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: RF
  states: {}

connections:
- [analog_rail_ff_1, '0', blocks_float_to_uchar_0, '0']
- [blocks_add_const_vxx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_complex_to_real_0, '0', virtual_sink_0, '0']
- [blocks_file_source_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [blocks_float_to_uchar_0, '0', blocks_file_sink_0, '0']
- [blocks_freqshift_cc_0, '0', blocks_complex_to_real_0, '0']
- [blocks_freqshift_cc_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', rational_resampler_xxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', analog_rail_ff_1, '0']
- [rational_resampler_xxx_0, '0', blocks_freqshift_cc_0, '0']
- [virtual_source_0, '0', blocks_add_const_vxx_0, '0']

metadata:
  file_format: 1
