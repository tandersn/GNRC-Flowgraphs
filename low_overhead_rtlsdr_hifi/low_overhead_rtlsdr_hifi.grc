options:
  parameters:
    generate_options: qt_gui
    id: adamr
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: NTSC
  id: variable
  parameters:
    value: '1500000'
  states: {}
- name: PAL
  id: variable
  parameters:
    value: '1600000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 8.192e6
  states: {}
- name: system
  id: variable
  parameters:
    value: NTSC
  states: {}
- name: analog_rail_ff_1
  id: analog_rail_ff
  parameters:
    hi: '255'
    lo: '0'
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    comment: output file is 8.192msps  use hifi decode  -f 8.192
    file: hifiout.u8
    type: byte
  states: {}
- name: blocks_float_to_uchar_0
  id: blocks_float_to_uchar
  parameters: {}
  states: {}
- name: blocks_freqshift_cc_0
  id: blocks_freqshift_cc
  parameters:
    freq: 1.5e6
    sample_rate: samp_rate
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '127'
    type: float
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '8'
    type: ccc
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    agc: '1'
    center_freq: system
    dev_args: dev=0,direct_samp=2,biastee=true
    gain: '10'
    samp_rate: 1.024e6
    type: fc32
  states: {}

connections:
- [analog_rail_ff_1, '0', blocks_float_to_uchar_0, '0']
- [blocks_add_const_vxx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_complex_to_real_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_float_to_uchar_0, '0', blocks_file_sink_0, '0']
- [blocks_freqshift_cc_0, '0', blocks_complex_to_real_0, '0']
- [blocks_freqshift_cc_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', analog_rail_ff_1, '0']
- [rational_resampler_xxx_0, '0', blocks_freqshift_cc_0, '0']
- [soapy_rtlsdr_source_0, '0', rational_resampler_xxx_0, '0']

metadata:
  file_format: 1
