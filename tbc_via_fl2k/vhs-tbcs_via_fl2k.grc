options:
  parameters:
    generate_options: qt_gui
    id: fl2k
    output_language: python
    title: Y and UV TBC streams to s8
  states: {}

blocks:
- name: line_length
  id: variable
  parameters:
    comment: |-
      910 NTSC
      1135 PAL
    value: '910'
  states: {}
- name: lines_per_frame
  id: variable
  parameters:
    comment: |-
      525 NTSC
      625 PAL
    value: '525'
  states: {}
- name: lines_per_frame_discard
  id: variable
  parameters:
    comment: |-
      Typically 1
      To discard last line
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 100e6
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '32768'
    type: float
  states: {}
- name: analog_const_source_x_0_0
  id: analog_const_source_x
  parameters:
    const: '32768'
    type: float
  states: {}
- name: analog_const_source_x_0_1
  id: analog_const_source_x
  parameters:
    const: '255'
    type: float
  states: {}
- name: analog_const_source_x_3
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {state: disabled}
- name: analog_const_source_x_5_0
  id: analog_const_source_x
  parameters:
    const: '127'
    type: float
  states: {}
- name: analog_rail_ff_0
  id: analog_rail_ff
  parameters:
    hi: '127'
    lo: '-127'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_0_1
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_2_0_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_2_0_1
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_deinterleave_0
  id: blocks_deinterleave
  parameters:
    type: float
  states: {}
- name: blocks_deinterleave_0_1
  id: blocks_deinterleave
  parameters:
    type: float
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    comment: Set output filename here
    file: /tmp/outfile.s8
    type: byte
  states: {state: disabled}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    comment: Input Luma TBC
    file: infile.tbc
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_file_source_0_0_0
  id: blocks_file_source
  parameters:
    comment: Input Chroma TBC
    file: infile_chroma.tbc
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_float_to_char_0
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {state: disabled}
- name: blocks_float_to_uchar_0
  id: blocks_float_to_uchar
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '256'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '256'
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
    vlen: line_length
  states: {}
- name: blocks_stream_demux_0
  id: blocks_stream_demux
  parameters:
    lengths: (lines_per_frame, lines_per_frame_discard)
    type: float
    vlen: line_length
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: line_length
    type: float
  states: {}
- name: blocks_sub_xx_2
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_2_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_uchar_to_float_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_0_0_1
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: line_length
    type: float
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: '"hackrf=0"'
    bb_gain0: '24'
    freq0: 655.25e6
    gain0: '14'
    if_gain0: '48'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: video_sdl_sink_0_0_0_0
  id: video_sdl_sink
  parameters:
    display_height: lines_per_frame
    display_width: line_length
    fps: '0'
    height: lines_per_frame
    type: byte
    width: line_length
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: yc
  states: {}
- name: virtual_source_2_1
  id: virtual_source
  parameters:
    stream_id: yc
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_sub_xx_2, '1']
- [analog_const_source_x_0_0, '0', blocks_sub_xx_2_0, '1']
- [analog_const_source_x_0_1, '0', blocks_divide_xx_0, '1']
- [analog_const_source_x_3, '0', blocks_float_to_complex_0, '1']
- [analog_const_source_x_5_0, '0', blocks_add_xx_2_0_0, '1']
- [analog_rail_ff_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_add_xx_0, '0', blocks_sub_xx_2_0, '0']
- [blocks_add_xx_0_1, '0', blocks_sub_xx_2, '0']
- [blocks_add_xx_2_0_0, '0', blocks_float_to_uchar_0, '0']
- [blocks_add_xx_2_0_1, '0', blocks_throttle_0_0, '0']
- [blocks_deinterleave_0, '0', blocks_add_xx_0, '0']
- [blocks_deinterleave_0, '1', blocks_multiply_const_vxx_0, '0']
- [blocks_deinterleave_0_1, '0', blocks_add_xx_0_1, '0']
- [blocks_deinterleave_0_1, '1', blocks_multiply_const_vxx_0_1, '0']
- [blocks_divide_xx_0, '0', virtual_sink_0, '0']
- [blocks_file_source_0_0, '0', blocks_uchar_to_float_0_0, '0']
- [blocks_file_source_0_0_0, '0', blocks_uchar_to_float_0_0_1, '0']
- [blocks_float_to_char_0, '0', blocks_file_sink_0, '0']
- [blocks_float_to_complex_0, '0', osmosdr_sink_0, '0']
- [blocks_float_to_uchar_0, '0', video_sdl_sink_0_0_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_0, '1']
- [blocks_multiply_const_vxx_0_1, '0', blocks_add_xx_0_1, '1']
- [blocks_stream_demux_0, '0', blocks_vector_to_stream_0, '0']
- [blocks_stream_demux_0, '1', blocks_null_sink_0, '0']
- [blocks_stream_to_vector_0, '0', blocks_stream_demux_0, '0']
- [blocks_sub_xx_2, '0', blocks_add_xx_2_0_1, '1']
- [blocks_sub_xx_2_0, '0', blocks_add_xx_2_0_1, '0']
- [blocks_throttle_0_0, '0', blocks_divide_xx_0, '0']
- [blocks_uchar_to_float_0_0, '0', blocks_deinterleave_0, '0']
- [blocks_uchar_to_float_0_0_1, '0', blocks_deinterleave_0_1, '0']
- [blocks_vector_to_stream_0, '0', blocks_add_xx_2_0_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_float_to_char_0, '0']
- [virtual_source_2_1, '0', analog_rail_ff_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.3.0
