options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 28.636363e6
  states: {}
- name: variable_qtgui_chooser_0
  id: variable_qtgui_chooser
  parameters:
    label: 8 or 16 Bit
    label0: 8 bit
    label1: 16 bit
    num_opts: '2'
    option0: '0'
    option1: '1'
    type: int
    value: '0'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '128'
    type: float
  states: {}
- name: analog_const_source_x_0_0
  id: analog_const_source_x
  parameters:
    const: '128'
    type: float
  states: {}
- name: analog_const_source_x_0_0_0
  id: analog_const_source_x
  parameters:
    const: '32768'
    type: float
  states: {}
- name: analog_const_source_x_0_0_0_0
  id: analog_const_source_x
  parameters:
    const: '32768'
    type: float
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_deinterleave_0
  id: blocks_deinterleave
  parameters:
    type: float
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_divide_xx_0_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /dev/cxadc0
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_float_to_uchar_0
  id: blocks_float_to_uchar
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '127'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '256'
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_1
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: '2'
    type: float
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: variable_qtgui_chooser_0
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_1
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_uchar_to_float_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Time Sink"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: video_sdl_sink_0
  id: video_sdl_sink
  parameters:
    alias: VIDEO
    display_height: '525'
    display_width: '910'
    fps: '0'
    height: '525'
    type: byte
    width: int(samp_rate/525/29.97)
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_sub_xx_0, '1']
- [analog_const_source_x_0_0, '0', blocks_divide_xx_0, '1']
- [analog_const_source_x_0_0_0, '0', blocks_sub_xx_1, '1']
- [analog_const_source_x_0_0_0_0, '0', blocks_divide_xx_0_0, '1']
- [blocks_add_const_vxx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_add_xx_0, '0', blocks_sub_xx_1, '0']
- [blocks_deinterleave_0, '0', blocks_add_xx_0, '0']
- [blocks_deinterleave_0, '1', blocks_multiply_const_vxx_0_0, '0']
- [blocks_divide_xx_0, '0', blocks_null_sink_0, '0']
- [blocks_divide_xx_0, '0', blocks_selector_0, '0']
- [blocks_divide_xx_0_0, '0', blocks_null_sink_0_1, '0']
- [blocks_divide_xx_0_0, '0', blocks_repeat_0, '0']
- [blocks_file_source_0, '0', blocks_uchar_to_float_0_0, '0']
- [blocks_float_to_uchar_0, '0', video_sdl_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_float_to_uchar_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_add_xx_0, '1']
- [blocks_repeat_0, '0', blocks_selector_0, '1']
- [blocks_selector_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_selector_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_sub_xx_0, '0', blocks_divide_xx_0, '0']
- [blocks_sub_xx_1, '0', blocks_divide_xx_0_0, '0']
- [blocks_uchar_to_float_0_0, '0', blocks_deinterleave_0, '0']
- [blocks_uchar_to_float_0_0, '0', blocks_sub_xx_0, '0']

metadata:
  file_format: 1
