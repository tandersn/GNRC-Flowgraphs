options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 28.636363e6
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '128'
    type: float
  states: {}
- name: analog_const_source_x_0_0
  id: analog_const_source_x
  parameters:
    const: '128'
    type: float
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /dev/cxadc0
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Time Sink"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: video_sdl_sink_0
  id: video_sdl_sink
  parameters:
    alias: VIDEO
    display_height: '600'
    display_width: '800'
    fps: '0'
    height: '525'
    type: byte
    width: int(samp_rate/525/29.97)
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_sub_xx_0, '1']
- [analog_const_source_x_0_0, '0', blocks_divide_xx_0, '1']
- [blocks_divide_xx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_file_source_0, '0', blocks_uchar_to_float_0, '0']
- [blocks_file_source_0, '0', video_sdl_sink_0, '0']
- [blocks_sub_xx_0, '0', blocks_divide_xx_0, '0']
- [blocks_uchar_to_float_0, '0', blocks_sub_xx_0, '0']

metadata:
  file_format: 1
