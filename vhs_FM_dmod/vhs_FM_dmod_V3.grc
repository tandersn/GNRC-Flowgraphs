options:
  parameters:
    generate_options: qt_gui
    id: vhs_demod
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    comment: do not change
    value: 40e6
  states: {}
- name: source_samp_rate
  id: variable
  parameters:
    comment: 5fsc = 17897726
    value: 20e6
  states: {}
- name: variable_band_pass_filter_taps_0
  id: variable_band_pass_filter_taps
  parameters:
    comment: 5.8e6 def
    gain: '1'
    high_cutoff_freq: 7.5e6
    low_cutoff_freq: 2e6
    samp_rate: samp_rate
    type: band_pass
    width: 500e3
    win: window.WIN_HAMMING
  states: {}
- name: variable_qtgui_range_0
  id: variable_qtgui_range
  parameters:
    comment: 7.35 spiderman
    label: OFFSET
    start: '0'
    step: '.05'
    stop: '10'
    value: '6.25'
  states: {}
- name: variable_qtgui_range_1
  id: variable_qtgui_range
  parameters:
    comment: 5.5 for spiderman and hercules
    label: GAIN
    start: '-10'
    step: '.1'
    stop: '10'
    value: '3.4'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '127'
    type: float
  states: {state: disabled}
- name: analog_const_source_x_0_0
  id: analog_const_source_x
  parameters:
    const: '127'
    type: float
  states: {state: disabled}
- name: analog_const_source_x_1_0_0
  id: analog_const_source_x
  parameters:
    const: '127'
    type: float
  states: {state: disabled}
- name: analog_const_source_x_1_0_1
  id: analog_const_source_x
  parameters:
    const: variable_qtgui_range_0
    type: float
  states: {}
- name: analog_fm_deemph_0
  id: analog_fm_deemph
  parameters:
    samp_rate: samp_rate
    tau: '125e-8'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate/(2*math.pi*1e6)+variable_qtgui_range_1
  states: {}
- name: analog_rail_ff_0
  id: analog_rail_ff
  parameters:
    hi: '255'
    lo: '0'
  states: {}
- name: analog_rail_ff_0_0
  id: analog_rail_ff
  parameters:
    hi: '127'
    lo: '-127'
  states: {state: disabled}
- name: analog_rail_ff_0_0_0
  id: analog_rail_ff
  parameters:
    hi: '.9999999'
    lo: '-.9999999'
  states: {}
- name: blocks_add_const_vxx_0_1
  id: blocks_add_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    comment: Signed 8 bit for FL2K
    file: /tmp/bsaddlesstopcopy.s8
    type: byte
  states: {state: disabled}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    comment: unsigned 8 output
    file: /tmp/vhs_fm_dmod_v3.u8
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    comment: cx card uncompressed 8 bit
    file: /dev/cxadc0
    repeat: 'False'
    type: byte
  states: {state: disabled}
- name: blocks_float_to_char_0
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_float_to_uchar_0
  id: blocks_float_to_uchar
  parameters: {}
  states: {state: disabled}
- name: blocks_float_to_uchar_1
  id: blocks_float_to_uchar
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_1_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '126'
    type: float
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_sub_xx_1_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_2
  id: blocks_sub_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    comment: |-
      wav file source seems
      to be able to read flac 
      files...
    file: /home/tandersn/DOWNLOADED_SAMPS/vhs/drfsup_blaz_sadd_30sec_20msps.flac
    repeat: 'False'
  states: {}
- name: fft_filter_xxx_0
  id: fft_filter_xxx
  parameters:
    decim: '1'
    nthreads: '12'
    taps: variable_band_pass_filter_taps_0
    type: ccc
  states: {}
- name: hilbert_fc_0
  id: hilbert_fc
  parameters:
    num_taps: '65'
  states: {}
- name: mmse_resampler_xx_0
  id: mmse_resampler_xx
  parameters:
    comment: 0.715909075  for 28.6
    phase_shift: '0'
    resamp_ratio: source_samp_rate/samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    size: '8092'
    srate: samp_rate
    type: float
  states: {}
- name: video_sdl_sink_0
  id: video_sdl_sink
  parameters:
    comment: round(samp_rate/525/29.97)
    display_height: round(samp_rate/525/29.97/2/4*3)
    display_width: round(samp_rate/525/29.97/2)
    fps: '30'
    height: '525'
    type: byte
    width: round(samp_rate/525/29.97)
  states: {state: disabled}

connections:
- [analog_const_source_x_0, '0', blocks_sub_xx_0, '1']
- [analog_const_source_x_0_0, '0', blocks_divide_xx_0, '1']
- [analog_const_source_x_1_0_0, '0', blocks_sub_xx_2, '1']
- [analog_const_source_x_1_0_1, '0', blocks_sub_xx_1_0, '1']
- [analog_fm_deemph_0, '0', blocks_sub_xx_1_0, '0']
- [analog_quadrature_demod_cf_0, '0', analog_fm_deemph_0, '0']
- [analog_rail_ff_0, '0', blocks_float_to_uchar_0, '0']
- [analog_rail_ff_0, '0', blocks_float_to_uchar_1, '0']
- [analog_rail_ff_0, '0', blocks_null_sink_0_0, '0']
- [analog_rail_ff_0, '0', blocks_sub_xx_2, '0']
- [analog_rail_ff_0_0, '0', blocks_float_to_char_0, '0']
- [analog_rail_ff_0_0_0, '0', blocks_add_const_vxx_0_1, '0']
- [blocks_add_const_vxx_0_1, '0', blocks_multiply_const_vxx_1_1, '0']
- [blocks_divide_xx_0, '0', blocks_throttle_0, '0']
- [blocks_divide_xx_0, '0', hilbert_fc_0, '0']
- [blocks_file_source_0, '0', blocks_uchar_to_float_0, '0']
- [blocks_float_to_char_0, '0', blocks_file_sink_0, '0']
- [blocks_float_to_uchar_0, '0', video_sdl_sink_0, '0']
- [blocks_float_to_uchar_1, '0', blocks_file_sink_1, '0']
- [blocks_multiply_const_vxx_1_1, '0', analog_rail_ff_0, '0']
- [blocks_sub_xx_0, '0', blocks_divide_xx_0, '0']
- [blocks_sub_xx_1_0, '0', analog_rail_ff_0_0_0, '0']
- [blocks_sub_xx_1_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_sub_xx_2, '0', analog_rail_ff_0_0, '0']
- [blocks_throttle_0, '0', blocks_null_sink_0, '0']
- [blocks_uchar_to_float_0, '0', blocks_sub_xx_0, '0']
- [blocks_wavfile_source_0, '0', blocks_throttle_0, '0']
- [blocks_wavfile_source_0, '0', hilbert_fc_0, '0']
- [fft_filter_xxx_0, '0', analog_quadrature_demod_cf_0, '0']
- [hilbert_fc_0, '0', mmse_resampler_xx_0, '0']
- [mmse_resampler_xx_0, '0', fft_filter_xxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
