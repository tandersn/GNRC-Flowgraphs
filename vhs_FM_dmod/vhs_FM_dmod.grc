options:
  parameters:
    generate_options: qt_gui
    id: ld_demod
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 40e6
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '127'
    type: float
  states: {state: disabled}
- name: analog_const_source_x_0_0
  id: analog_const_source_x
  parameters:
    const: '127'
    type: float
  states: {state: disabled}
- name: analog_const_source_x_1
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: analog_const_source_x_1_0
  id: analog_const_source_x
  parameters:
    const: '730'
    type: float
  states: {}
- name: analog_const_source_x_1_0_0
  id: analog_const_source_x
  parameters:
    const: '127'
    type: float
  states: {state: disabled}
- name: analog_fm_deemph_0
  id: analog_fm_deemph
  parameters:
    samp_rate: samp_rate
    tau: '125e-8'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate/(2*math.pi*1e6)
  states: {}
- name: analog_rail_ff_0
  id: analog_rail_ff
  parameters:
    hi: '255'
    lo: '1'
  states: {}
- name: analog_rail_ff_0_0
  id: analog_rail_ff
  parameters:
    hi: '127'
    lo: '-127'
  states: {state: disabled}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: 4.5e6
    low_cutoff_freq: 3.3e6
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 500e3
    win: window.WIN_HAMMING
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /tmp/ld_fm_dmod_out_4fl2k.s8
    type: byte
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    comment: cx card uncompressed 8 bit
    file: /laserdisc/captures/movies_and_demos/shortestdisc.r8
    repeat: 'False'
    type: byte
  states: {state: disabled}
- name: blocks_float_to_char_0
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    scale: '1'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '220'
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_sub_xx_1
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_2
  id: blocks_sub_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    comment: |-
      wav file source seems
      to be able to read flac 
      files...
    file: /home/tandersn/DISK/laserdisc/captures/spinning/downloaded_samples/test40-rate40k.flac
    repeat: 'True'
  states: {}
- name: hilbert_fc_0
  id: hilbert_fc
  parameters:
    num_taps: '65'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    nconnections: '2'
    size: '4096'
    srate: 40e6
    type: float
    ymax: '255'
    ymin: '-3'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '2'
    interp: '1'
    type: fff
  states: {}
- name: video_sdl_sink_0
  id: video_sdl_sink
  parameters:
    display_height: '1050'
    display_width: '1271'
    fps: '30'
    height: '525'
    type: short
    width: round(samp_rate/525/29.97/2)
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_sub_xx_0, '1']
- [analog_const_source_x_0_0, '0', blocks_divide_xx_0, '1']
- [analog_const_source_x_1, '0', qtgui_time_sink_x_0_0, '1']
- [analog_const_source_x_1_0, '0', blocks_sub_xx_1, '1']
- [analog_const_source_x_1_0_0, '0', blocks_sub_xx_2, '1']
- [analog_fm_deemph_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_quadrature_demod_cf_0, '0', analog_fm_deemph_0, '0']
- [analog_rail_ff_0, '0', blocks_float_to_short_0, '0']
- [analog_rail_ff_0, '0', blocks_null_sink_0_0, '0']
- [analog_rail_ff_0, '0', blocks_sub_xx_2, '0']
- [analog_rail_ff_0_0, '0', blocks_float_to_char_0, '0']
- [band_pass_filter_0, '0', analog_quadrature_demod_cf_0, '0']
- [blocks_divide_xx_0, '0', blocks_throttle_0, '0']
- [blocks_divide_xx_0, '0', hilbert_fc_0, '0']
- [blocks_file_source_0, '0', blocks_uchar_to_float_0, '0']
- [blocks_float_to_char_0, '0', blocks_file_sink_0, '0']
- [blocks_float_to_short_0, '0', video_sdl_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_sub_xx_1, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_sub_xx_0, '0', blocks_divide_xx_0, '0']
- [blocks_sub_xx_1, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_sub_xx_1, '0', rational_resampler_xxx_0, '0']
- [blocks_sub_xx_2, '0', analog_rail_ff_0_0, '0']
- [blocks_throttle_0, '0', blocks_null_sink_0, '0']
- [blocks_uchar_to_float_0, '0', blocks_sub_xx_0, '0']
- [blocks_wavfile_source_0, '0', blocks_throttle_0, '0']
- [blocks_wavfile_source_0, '0', hilbert_fc_0, '0']
- [hilbert_fc_0, '0', band_pass_filter_0, '0']
- [rational_resampler_xxx_0, '0', analog_rail_ff_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.2.0
