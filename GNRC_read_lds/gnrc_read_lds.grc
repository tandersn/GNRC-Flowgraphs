options:
  parameters:
    generate_options: qt_gui
    id: gnrc_read_lds
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 40e6
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: byte
  states: {state: disabled}
- name: analog_const_source_x_0_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: byte
  states: {state: disabled}
- name: analog_const_source_x_0_0_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: byte
  states: {state: disabled}
- name: analog_const_source_x_0_0_0_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: byte
  states: {}
- name: analog_const_source_x_0_0_1
  id: analog_const_source_x
  parameters:
    const: '0'
    type: byte
  states: {state: disabled}
- name: analog_const_source_x_0_0_1_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: byte
  states: {}
- name: analog_const_source_x_0_0_2
  id: analog_const_source_x
  parameters:
    const: '0'
    type: byte
  states: {}
- name: analog_const_source_x_0_1
  id: analog_const_source_x
  parameters:
    const: '0'
    type: byte
  states: {state: disabled}
- name: analog_const_source_x_0_1_0
  id: analog_const_source_x
  parameters:
    const: '32768'
    type: float
  states: {}
- name: analog_const_source_x_0_1_1
  id: analog_const_source_x
  parameters:
    const: '0'
    type: byte
  states: {}
- name: analog_const_source_x_0_2
  id: analog_const_source_x
  parameters:
    const: '0'
    type: byte
  states: {state: disabled}
- name: analog_const_source_x_0_2_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: byte
  states: {}
- name: analog_const_source_x_0_3
  id: analog_const_source_x
  parameters:
    const: '1'
    type: float
  states: {}
- name: analog_const_source_x_0_4
  id: analog_const_source_x
  parameters:
    const: '0'
    type: byte
  states: {}
- name: blocks_add_xx_0_1
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_deinterleave_0
  id: blocks_deinterleave
  parameters:
    num_streams: '10'
    type: byte
  states: {state: disabled}
- name: blocks_deinterleave_0_0
  id: blocks_deinterleave
  parameters:
    num_streams: '10'
    type: byte
  states: {}
- name: blocks_divide_xx_0_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /laserdisc/captures/spinning/downloaded_samples/ds9Spydr3test.lds
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: /laserdisc/captures/spinning/downloaded_samples/ds9Spydr3test.lds
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_interleave_0
  id: blocks_interleave
  parameters:
    num_streams: '16'
    type: byte
  states: {state: disabled}
- name: blocks_interleave_0_0
  id: blocks_interleave
  parameters:
    num_streams: '8'
    type: byte
  states: {}
- name: blocks_interleave_0_0_0
  id: blocks_interleave
  parameters:
    num_streams: '8'
    type: byte
  states: {}
- name: blocks_multiply_const_vxx_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '256'
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_1
  id: blocks_null_sink
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_pack_k_bits_bb_0_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_sub_xx_2
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_uchar_to_float_0_0_1
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_0_0_1_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {state: disabled}
- name: blocks_unpack_k_bits_bb_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample2: FORMAT_PCM_16
    file: /tmp/1.flac
    format: FORMAT_FLAC
    samp_rate: '40000'
  states: {}
- name: blocks_wavfile_sink_0_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample2: FORMAT_PCM_16
    file: /tmp/2.flac
    format: FORMAT_FLAC
    samp_rate: '40000'
  states: {state: disabled}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /laserdisc/captures/spinning/downloaded_samples/ds9Spydr3test.flac
    repeat: 'True'
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    nconnections: '2'
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_interleave_0, '10']
- [analog_const_source_x_0_0, '0', blocks_interleave_0, '13']
- [analog_const_source_x_0_0_0, '0', blocks_interleave_0, '14']
- [analog_const_source_x_0_0_0_0, '0', blocks_interleave_0_0, '6']
- [analog_const_source_x_0_0_1, '0', blocks_interleave_0, '15']
- [analog_const_source_x_0_0_1_0, '0', blocks_interleave_0_0, '7']
- [analog_const_source_x_0_0_2, '0', blocks_interleave_0_0, '5']
- [analog_const_source_x_0_1, '0', blocks_interleave_0, '11']
- [analog_const_source_x_0_1_0, '0', blocks_divide_xx_0_0, '1']
- [analog_const_source_x_0_1_1, '0', blocks_interleave_0_0, '3']
- [analog_const_source_x_0_2, '0', blocks_interleave_0, '12']
- [analog_const_source_x_0_2_0, '0', blocks_interleave_0_0, '4']
- [analog_const_source_x_0_3, '0', blocks_sub_xx_2, '1']
- [analog_const_source_x_0_4, '0', blocks_interleave_0_0, '2']
- [blocks_add_xx_0_1, '0', blocks_divide_xx_0_0, '0']
- [blocks_deinterleave_0, '0', blocks_interleave_0, '0']
- [blocks_deinterleave_0, '1', blocks_interleave_0, '1']
- [blocks_deinterleave_0, '2', blocks_interleave_0, '2']
- [blocks_deinterleave_0, '3', blocks_interleave_0, '3']
- [blocks_deinterleave_0, '4', blocks_interleave_0, '4']
- [blocks_deinterleave_0, '5', blocks_interleave_0, '5']
- [blocks_deinterleave_0, '6', blocks_interleave_0, '6']
- [blocks_deinterleave_0, '7', blocks_interleave_0, '7']
- [blocks_deinterleave_0, '8', blocks_interleave_0, '8']
- [blocks_deinterleave_0, '9', blocks_interleave_0, '9']
- [blocks_deinterleave_0_0, '0', blocks_interleave_0_0_0, '0']
- [blocks_deinterleave_0_0, '1', blocks_interleave_0_0_0, '1']
- [blocks_deinterleave_0_0, '2', blocks_interleave_0_0_0, '2']
- [blocks_deinterleave_0_0, '3', blocks_interleave_0_0_0, '3']
- [blocks_deinterleave_0_0, '4', blocks_interleave_0_0_0, '4']
- [blocks_deinterleave_0_0, '5', blocks_interleave_0_0_0, '5']
- [blocks_deinterleave_0_0, '6', blocks_interleave_0_0_0, '6']
- [blocks_deinterleave_0_0, '7', blocks_interleave_0_0_0, '7']
- [blocks_deinterleave_0_0, '8', blocks_interleave_0_0, '0']
- [blocks_deinterleave_0_0, '9', blocks_interleave_0_0, '1']
- [blocks_divide_xx_0_0, '0', blocks_sub_xx_2, '0']
- [blocks_file_source_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [blocks_file_source_0_0, '0', blocks_unpack_k_bits_bb_0_0, '0']
- [blocks_interleave_0_0, '0', blocks_pack_k_bits_bb_0_0, '0']
- [blocks_interleave_0_0_0, '0', blocks_pack_k_bits_bb_0, '0']
- [blocks_multiply_const_vxx_0_1, '0', blocks_add_xx_0_1, '0']
- [blocks_pack_k_bits_bb_0, '0', blocks_uchar_to_float_0_0_1_0, '0']
- [blocks_pack_k_bits_bb_0_0, '0', blocks_uchar_to_float_0_0_1, '0']
- [blocks_sub_xx_2, '0', blocks_throttle_0, '0']
- [blocks_sub_xx_2, '0', qtgui_number_sink_0, '0']
- [blocks_throttle_0, '0', blocks_wavfile_sink_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_throttle_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_uchar_to_float_0_0_1, '0', blocks_add_xx_0_1, '1']
- [blocks_uchar_to_float_0_0_1, '0', blocks_null_sink_0, '0']
- [blocks_uchar_to_float_0_0_1_0, '0', blocks_multiply_const_vxx_0_1, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_deinterleave_0, '0']
- [blocks_unpack_k_bits_bb_0_0, '0', blocks_deinterleave_0_0, '0']
- [blocks_wavfile_source_0, '0', blocks_wavfile_sink_0_0, '0']
- [blocks_wavfile_source_0, '0', qtgui_number_sink_0, '1']
- [blocks_wavfile_source_0, '0', qtgui_time_sink_x_0_0, '0']

metadata:
  file_format: 1
