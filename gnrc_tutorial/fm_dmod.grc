options:
  parameters:
    generate_options: qt_gui
    id: fm_dmod
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 40e6
  states: {}
- name: analog_const_source_x_1
  id: analog_const_source_x
  parameters:
    const: '-1'
    type: float
  states: {}
- name: analog_const_source_x_1_0
  id: analog_const_source_x
  parameters:
    const: '9.67'
    type: float
  states: {}
- name: analog_const_source_x_1_0_0
  id: analog_const_source_x
  parameters:
    const: '127'
    type: float
  states: {}
- name: analog_const_source_x_1_1
  id: analog_const_source_x
  parameters:
    const: '1'
    type: float
  states: {}
- name: analog_fm_deemph_0
  id: analog_fm_deemph
  parameters:
    comment: |-
      was 1e-8

      good 17e-8
    samp_rate: samp_rate
    tau: '17e-8'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate/(2*math.pi*1.7e6)
  states: {}
- name: analog_rail_ff_0
  id: analog_rail_ff
  parameters:
    hi: '255'
    lo: '1'
  states: {}
- name: analog_rail_ff_1
  id: analog_rail_ff
  parameters:
    hi: '1'
    lo: '-1'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    comment: transition was 500k
    decim: '1'
    gain: '1'
    high_cutoff_freq: 13.8e6
    low_cutoff_freq: 3.4e6
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 100e3
    win: window.WIN_HAMMING
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: source.s16
    repeat: 'False'
    type: short
  states: {}
- name: blocks_float_to_uchar_0
  id: blocks_float_to_uchar
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1.942'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '127'
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '32768'
  states: {}
- name: blocks_sub_xx_1
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: hilbert_fc_0
  id: hilbert_fc
  parameters:
    num_taps: '65'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    nconnections: '3'
    size: '4096'
    srate: 54e6
    type: float
    ymax: '1.2'
    ymin: '-1.2'
  states: {}
- name: video_sdl_sink_0
  id: video_sdl_sink
  parameters:
    display_height: '480'
    display_width: '640'
    fps: '30'
    height: '525'
    type: byte
    width: round(samp_rate/525/29.97)
  states: {}
- name: video_sdl_sink_0_0
  id: video_sdl_sink
  parameters:
    display_height: '1050'
    display_width: '1271'
    fps: '30'
    height: '525'
    type: short
    width: round(samp_rate/525/29.97)
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: wrap1
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: wrap1
  states: {}

connections:
- [analog_const_source_x_1, '0', qtgui_time_sink_x_0_0, '1']
- [analog_const_source_x_1_0, '0', blocks_sub_xx_1, '1']
- [analog_const_source_x_1_0_0, '0', blocks_add_xx_0, '1']
- [analog_const_source_x_1_1, '0', qtgui_time_sink_x_0_0, '2']
- [analog_fm_deemph_0, '0', virtual_sink_0, '0']
- [analog_quadrature_demod_cf_0, '0', analog_fm_deemph_0, '0']
- [analog_rail_ff_0, '0', blocks_float_to_uchar_0, '0']
- [analog_rail_ff_1, '0', blocks_multiply_const_vxx_1, '0']
- [band_pass_filter_0, '0', analog_quadrature_demod_cf_0, '0']
- [blocks_add_xx_0, '0', analog_rail_ff_0, '0']
- [blocks_file_source_0, '0', blocks_short_to_float_0, '0']
- [blocks_float_to_uchar_0, '0', video_sdl_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_sub_xx_1, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_add_xx_0, '0']
- [blocks_short_to_float_0, '0', blocks_throttle_0, '0']
- [blocks_short_to_float_0, '0', hilbert_fc_0, '0']
- [blocks_sub_xx_1, '0', analog_rail_ff_1, '0']
- [blocks_sub_xx_1, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_throttle_0, '0', blocks_null_sink_0, '0']
- [hilbert_fc_0, '0', band_pass_filter_0, '0']
- [virtual_source_0, '0', blocks_multiply_const_vxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.3.0
