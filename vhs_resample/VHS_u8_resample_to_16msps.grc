options:
  parameters:
    generate_options: qt_gui
    id: bs
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    comment: do not change
    value: 16e6
  states: {}
- name: source_samp_rate
  id: variable
  parameters:
    comment: 5fsc = 17897726
    value: 54e6
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '127'
    type: float
  states: {}
- name: analog_const_source_x_0_0
  id: analog_const_source_x
  parameters:
    const: '128'
    type: float
  states: {}
- name: analog_rail_ff_0
  id: analog_rail_ff
  parameters:
    hi: '1'
    lo: '-1'
  states: {}
- name: analog_rail_ff_0_0
  id: analog_rail_ff
  parameters:
    hi: '1'
    lo: '-1'
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /VHS/captures/spinning/Sc00b_771hf_m1uf100otOPA657_smOrnBNC_ex49rtt_mZipG54cx1dxvx1_cat_16resamp.r8
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /VHS/captures/spinning/Sc00b_771hf_m1uf100otOPA657_smOrnBNC_ex49rtt_mZipG54cx1dxvx1_cat.r8
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_float_to_uchar_0
  id: blocks_float_to_uchar
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '127'
    type: float
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: filter_fft_low_pass_filter_0
  id: filter_fft_low_pass_filter
  parameters:
    cutoff_freq: 7.5e6
    decim: '1'
    gain: '1'
    nthreads: '20'
    samp_rate: source_samp_rate
    type: fff
    width: '100000'
    win: window.WIN_HAMMING
  states: {}
- name: hilbert_fc_0
  id: hilbert_fc
  parameters:
    num_taps: '65'
  states: {}
- name: mmse_resampler_xx_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: source_samp_rate/samp_rate
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: source_samp_rate
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    type: float
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: RF
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: RF
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_divide_xx_0, '1']
- [analog_const_source_x_0_0, '0', blocks_sub_xx_0, '1']
- [analog_rail_ff_0, '0', filter_fft_low_pass_filter_0, '0']
- [analog_rail_ff_0_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_add_const_vxx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_complex_to_real_0, '0', analog_rail_ff_0_0, '0']
- [blocks_divide_xx_0, '0', analog_rail_ff_0, '0']
- [blocks_file_source_0, '0', blocks_uchar_to_float_0, '0']
- [blocks_float_to_uchar_0, '0', blocks_file_sink_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_float_to_uchar_0, '0']
- [blocks_sub_xx_0, '0', blocks_divide_xx_0, '0']
- [blocks_uchar_to_float_0, '0', blocks_sub_xx_0, '0']
- [filter_fft_low_pass_filter_0, '0', qtgui_freq_sink_x_0, '0']
- [filter_fft_low_pass_filter_0, '0', virtual_sink_0, '0']
- [hilbert_fc_0, '0', mmse_resampler_xx_0, '0']
- [mmse_resampler_xx_0, '0', blocks_complex_to_real_0, '0']
- [virtual_source_0, '0', hilbert_fc_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
