options:
  parameters:
    generate_options: qt_gui
    id: colordecode
    output_language: python
    title: Extract VITS line
  states: {}

blocks:
- name: PAL_xtra
  id: variable
  parameters:
    value: int(disp_columns)+int(disp_lines/600)
  states: {}
- name: disp_columns
  id: variable
  parameters:
    comment: |-
      910 NTSC
      1135 PAL
    value: '910'
  states: {}
- name: disp_lines
  id: variable
  parameters:
    comment: |-
      526 NTSC
      626 PAL
    value: '526'
  states: {}
- name: repeat_times
  id: variable
  parameters:
    comment: |-
      number of times 
      to repeat each
      line
    value: '20'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '14318181'
  states: {}
- name: start_line
  id: variable
  parameters:
    comment: |-
      Line to start 
      display at
    value: '0'
  states: {}
- name: view_lines
  id: variable
  parameters:
    comment: |-
      numbre of lines
      to show
    value: '44'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '32768'
    type: float
  states: {}
- name: analog_const_source_x_1
  id: analog_const_source_x
  parameters:
    const: '1'
    type: float
  states: {}
- name: analog_const_source_x_2
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: analog_rail_ff_1
  id: analog_rail_ff
  parameters:
    hi: '1'
    lo: '-1'
  states: {}
- name: analog_rail_ff_2
  id: analog_rail_ff
  parameters:
    hi: '254'
    lo: '1'
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_add_const_vxx_1
  id: blocks_add_const_vxx
  parameters:
    const: '1'
    type: float
  states: {state: disabled}
- name: blocks_add_xx_0_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_deinterleave_0
  id: blocks_deinterleave
  parameters:
    type: float
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    comment: |-
      example ffmpeg / ffplay command:

      ffplay -f rawvideo -pix_fmt gray8 -video_size 910x880 -i /tmp/outfile.u8

      where width is NTSC 910 and height is
      view_lines * repeat_times = 880
    file: /tmp/outfile.u8
    type: byte
  states: {state: disabled}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    comment: |-
      edit to set
      input TBC file
    file: /laserdisc/captures/movies_and_demos/out/4300D_rfTap_100IOTopa657_13+_grn54c2_16x33.75_bi50t_dxvx2_fan_50k150ciCXlvladj_critSe7enC47.u16.tbc
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    scale: '1'
  states: {}
- name: blocks_float_to_uchar_0
  id: blocks_float_to_uchar
  parameters: {}
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '126'
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '256'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '127'
    type: float
  states: {}
- name: blocks_null_sink_2
  id: blocks_null_sink
  parameters:
    type: float
    vlen: PAL_xtra
  states: {}
- name: blocks_null_sink_2_0
  id: blocks_null_sink
  parameters:
    type: float
    vlen: PAL_xtra
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: repeat_times
    type: float
    vlen: PAL_xtra
  states: {}
- name: blocks_stream_demux_0
  id: blocks_stream_demux
  parameters:
    lengths: (start_line,view_lines, int( disp_lines-view_lines-start_line))
    num_outputs: '3'
    type: float
    vlen: PAL_xtra
  states: {}
- name: blocks_stream_mux_0_0
  id: blocks_stream_mux
  parameters:
    lengths: (1, 1)
    type: float
    vlen: PAL_xtra
  states: {}
- name: blocks_stream_mux_1
  id: blocks_stream_mux
  parameters:
    lengths: (disp_columns, int(PAL_xtra-disp_columns))
    type: float
  states: {}
- name: blocks_stream_to_streams_0
  id: blocks_stream_to_streams
  parameters:
    type: float
    vlen: int(PAL_xtra*disp_lines/2)
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: int(PAL_xtra*disp_lines/2)
    type: float
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_vector_to_stream_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: round(disp_lines/2)
    type: float
    vlen: PAL_xtra
  states: {}
- name: blocks_vector_to_stream_0_1
  id: blocks_vector_to_stream
  parameters:
    num_items: round(disp_lines/2)
    type: float
    vlen: PAL_xtra
  states: {}
- name: blocks_vector_to_stream_1
  id: blocks_vector_to_stream
  parameters:
    num_items: PAL_xtra
    type: float
  states: {}
- name: note_0
  id: note
  parameters:
    note: Enable to save a file
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    size: '2048'
    srate: samp_rate
    type: float
    ymax: '1.1'
    ymin: '-1.1'
  states: {}
- name: video_sdl_sink_0_1_0
  id: video_sdl_sink
  parameters:
    comment: |-
      Use values shown above
      for ffplay dimensions
    display_height: int(view_lines*repeat_times)
    display_width: PAL_xtra
    fps: '29.97'
    height: int(view_lines*repeat_times)
    type: short
    width: PAL_xtra
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: A
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: A
  states: {state: disabled}

connections:
- [analog_const_source_x_0, '0', blocks_divide_xx_0, '1']
- [analog_const_source_x_1, '0', blocks_sub_xx_0, '1']
- [analog_const_source_x_2, '0', blocks_stream_mux_1, '1']
- [analog_rail_ff_1, '0', blocks_stream_mux_1, '0']
- [analog_rail_ff_2, '0', blocks_float_to_short_0, '0']
- [blocks_add_const_vxx_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_add_const_vxx_1, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_add_xx_0_0, '0', blocks_throttle_0_0, '0']
- [blocks_deinterleave_0, '0', blocks_add_xx_0_0, '0']
- [blocks_deinterleave_0, '1', blocks_multiply_const_vxx_0_0, '0']
- [blocks_divide_xx_0, '0', blocks_sub_xx_0, '0']
- [blocks_file_source_0_0, '0', blocks_uchar_to_float_0, '0']
- [blocks_float_to_short_0, '0', video_sdl_sink_0_1_0, '0']
- [blocks_float_to_uchar_0, '0', blocks_file_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_float_to_uchar_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_add_xx_0_0, '1']
- [blocks_multiply_const_vxx_1, '0', analog_rail_ff_2, '0']
- [blocks_repeat_0, '0', blocks_vector_to_stream_1, '0']
- [blocks_stream_demux_0, '0', blocks_null_sink_2_0, '0']
- [blocks_stream_demux_0, '1', blocks_repeat_0, '0']
- [blocks_stream_demux_0, '2', blocks_null_sink_2, '0']
- [blocks_stream_mux_0_0, '0', blocks_stream_demux_0, '0']
- [blocks_stream_mux_1, '0', blocks_stream_to_vector_0, '0']
- [blocks_stream_to_streams_0, '0', blocks_vector_to_stream_0_1, '0']
- [blocks_stream_to_streams_0, '1', blocks_vector_to_stream_0_0, '0']
- [blocks_stream_to_vector_0, '0', blocks_stream_to_streams_0, '0']
- [blocks_sub_xx_0, '0', analog_rail_ff_1, '0']
- [blocks_throttle_0_0, '0', blocks_divide_xx_0, '0']
- [blocks_uchar_to_float_0, '0', blocks_deinterleave_0, '0']
- [blocks_vector_to_stream_0_0, '0', blocks_stream_mux_0_0, '1']
- [blocks_vector_to_stream_0_1, '0', blocks_stream_mux_0_0, '0']
- [blocks_vector_to_stream_1, '0', blocks_add_const_vxx_0, '0']
- [blocks_vector_to_stream_1, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_vector_to_stream_1, '0', virtual_sink_0, '0']
- [virtual_source_0, '0', blocks_add_const_vxx_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.2.0
