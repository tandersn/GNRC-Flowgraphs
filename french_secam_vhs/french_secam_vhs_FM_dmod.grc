options:
  parameters:
    generate_options: qt_gui
    id: ld_demod
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: color_FM_badwidth
  id: variable
  parameters:
    value: '87500'
  states: {}
- name: colordelay
  id: variable
  parameters:
    comment: |-
      885 with band pass enabled
      1100 without band pass enabled
    value: '400'
  states: {}
- name: fm_demph
  id: variable
  parameters:
    value: '160e-8'
  states: {}
- name: line_length
  id: variable
  parameters:
    value: round(samp_rate/625/25)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 40e6
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '127'
    type: float
  states: {state: disabled}
- name: analog_const_source_x_0_0
  id: analog_const_source_x
  parameters:
    const: '127'
    type: float
  states: {state: disabled}
- name: analog_const_source_x_1
  id: analog_const_source_x
  parameters:
    const: '0'
    type: complex
  states: {state: disabled}
- name: analog_const_source_x_1_0
  id: analog_const_source_x
  parameters:
    const: '840'
    type: float
  states: {}
- name: analog_const_source_x_1_0_1
  id: analog_const_source_x
  parameters:
    const: '6.1'
    type: float
  states: {}
- name: analog_const_source_x_1_1
  id: analog_const_source_x
  parameters:
    const: '6.3'
    type: float
  states: {}
- name: analog_const_source_x_2
  id: analog_const_source_x
  parameters:
    const: '127'
    type: byte
  states: {state: disabled}
- name: analog_const_source_x_2_0
  id: analog_const_source_x
  parameters:
    const: '127'
    type: byte
  states: {state: disabled}
- name: analog_fm_deemph_0
  id: analog_fm_deemph
  parameters:
    samp_rate: samp_rate
    tau: '125e-8'
  states: {}
- name: analog_fm_deemph_0_0_0
  id: analog_fm_deemph
  parameters:
    samp_rate: samp_rate
    tau: fm_demph
  states: {}
- name: analog_fm_deemph_0_1
  id: analog_fm_deemph
  parameters:
    samp_rate: samp_rate
    tau: fm_demph
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate/(2*math.pi*1e6)
  states: {}
- name: analog_quadrature_demod_cf_0_0_0
  id: analog_quadrature_demod_cf
  parameters:
    comment: |-
      87500 on upconverted worked well

      Db
    gain: samp_rate/(2*math.pi*color_FM_badwidth)
  states: {}
- name: analog_quadrature_demod_cf_0_1
  id: analog_quadrature_demod_cf
  parameters:
    comment: |-
      87500 on upconverted worked well

      Dr
    gain: samp_rate/(2*math.pi*color_FM_badwidth)
  states: {}
- name: analog_rail_ff_0
  id: analog_rail_ff
  parameters:
    hi: '255'
    lo: '1'
  states: {}
- name: analog_rail_ff_0_0_0
  id: analog_rail_ff
  parameters:
    hi: '1'
    lo: '-1'
  states: {}
- name: analog_rail_ff_0_0_0_0
  id: analog_rail_ff
  parameters:
    hi: '0'
    lo: '-2'
  states: {}
- name: analog_rail_ff_0_0_0_0_0
  id: analog_rail_ff
  parameters:
    hi: '0'
    lo: '-2'
  states: {state: disabled}
- name: analog_rail_ff_0_0_0_1
  id: analog_rail_ff
  parameters:
    hi: '2'
    lo: '0'
  states: {}
- name: analog_rail_ff_0_0_0_1_0
  id: analog_rail_ff
  parameters:
    hi: '2'
    lo: '0'
  states: {state: disabled}
- name: analog_rail_ff_0_0_1
  id: analog_rail_ff
  parameters:
    hi: '1'
    lo: '-1'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: 7e6
    low_cutoff_freq: 2e6
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 500e3
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_0
  id: band_pass_filter
  parameters:
    comment: 1.1mhz center
    decim: '1'
    gain: '1'
    high_cutoff_freq: 1.6e6
    low_cutoff_freq: 600e3
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 49e3
    win: window.WIN_HAMMING
  states: {}
- name: blocks_abs_xx_0
  id: blocks_abs_xx
  parameters:
    type: float
  states: {}
- name: blocks_abs_xx_0_0
  id: blocks_abs_xx
  parameters:
    type: float
  states: {}
- name: blocks_abs_xx_0_0_0
  id: blocks_abs_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_abs_xx_0_1
  id: blocks_abs_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_add_const_vxx_0_0
  id: blocks_add_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_add_const_vxx_0_0_0
  id: blocks_add_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {state: disabled}
- name: blocks_add_const_vxx_0_1
  id: blocks_add_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_add_const_vxx_0_1_1
  id: blocks_add_const_vxx
  parameters:
    const: '1'
    type: float
  states: {state: disabled}
- name: blocks_deinterleave_1_0
  id: blocks_deinterleave
  parameters:
    type: float
    vlen: line_length
  states: {}
- name: blocks_deinterleave_1_0_0
  id: blocks_deinterleave
  parameters:
    type: float
    vlen: line_length
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: colordelay
    type: float
  states: {}
- name: blocks_delay_0_0_0
  id: blocks_delay
  parameters:
    delay: round(line_length/2)+50
    type: float
  states: {}
- name: blocks_delay_0_1
  id: blocks_delay
  parameters:
    delay: colordelay
    type: float
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    comment: cx card uncompressed 8 bit
    file: /dev/cxadc0
    repeat: 'False'
    type: byte
  states: {state: disabled}
- name: blocks_file_source_1
  id: blocks_file_source
  parameters:
    file: /home/tandersn/CAPTURES/spinning/downloaded_samples/vrunk/Secam_L_matrix_RF-Sample_2022-05-26_14-10-32.s16
    repeat: 'False'
    type: short
  states: {state: disabled}
- name: blocks_float_to_uchar_0
  id: blocks_float_to_uchar
  parameters: {}
  states: {}
- name: blocks_float_to_uchar_0_0
  id: blocks_float_to_uchar
  parameters: {}
  states: {}
- name: blocks_float_to_uchar_0_1
  id: blocks_float_to_uchar
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '220'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '127'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '127'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_2
  id: blocks_multiply_const_vxx
  parameters:
    const: '.5'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_2_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '.5'
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_0_1
  id: blocks_null_sink
  parameters:
    type: float
    vlen: line_length
  states: {}
- name: blocks_null_sink_0_1
  id: blocks_null_sink
  parameters:
    type: float
    vlen: line_length
  states: {}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_repeat_0_0_2
  id: blocks_repeat
  parameters:
    interp: '2'
    type: float
    vlen: line_length
  states: {}
- name: blocks_repeat_0_0_2_0
  id: blocks_repeat
  parameters:
    interp: '2'
    type: float
    vlen: line_length
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '8000'
  states: {state: disabled}
- name: blocks_stream_demux_1
  id: blocks_stream_demux
  parameters:
    lengths: (1400, 150 , line_length-1550)
    num_outputs: '3'
    type: complex
  states: {state: disabled}
- name: blocks_stream_mux_0
  id: blocks_stream_mux
  parameters:
    lengths: (1400, 150 , line_length-1550)
    num_inputs: '3'
    type: complex
  states: {state: disabled}
- name: blocks_stream_to_vector_0_0_1_0_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: line_length
    type: float
  states: {}
- name: blocks_stream_to_vector_0_0_1_0_0_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: line_length
    type: float
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_sub_xx_0_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_0_0_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_1
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_vector_to_stream_0_2_1
  id: blocks_vector_to_stream
  parameters:
    num_items: line_length
    type: float
  states: {}
- name: blocks_vector_to_stream_0_2_1_0
  id: blocks_vector_to_stream
  parameters:
    num_items: line_length
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    comment: |-
      wav file source seems
      to be able to read flac 
      files...
    file: /laserdisc/captures/spinning/downloaded_samples/vhs/SECAM/Secam_Lmatrix_RF-Sample_2022-05-26_14-10-32_secam_matrix_end.flac
    repeat: 'False'
  states: {}
- name: hilbert_fc_0
  id: hilbert_fc
  parameters:
    num_taps: '65'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    nconnections: '2'
    size: '100000'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    nconnections: '2'
    size: '4096'
    srate: samp_rate
    type: float
    ymax: '255'
    ymin: '-3'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: video_sdl_sink_0
  id: video_sdl_sink
  parameters:
    comment: round(samp_rate/625/25)
    display_height: '625'
    display_width: '1024'
    fps: '25'
    height: '625'
    num_channels: '3'
    type: byte
    width: round(samp_rate/625/25)
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: y
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: c
  states: {}
- name: virtual_sink_0_0_0
  id: virtual_sink
  parameters:
    stream_id: Db
  states: {}
- name: virtual_sink_0_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: Dr
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: y
  states: {}
- name: virtual_source_2_1_0
  id: virtual_source
  parameters:
    stream_id: c
  states: {}
- name: virtual_source_2_1_0_0
  id: virtual_source
  parameters:
    stream_id: Dr
  states: {}
- name: virtual_source_2_1_0_0_0
  id: virtual_source
  parameters:
    stream_id: Db
  states: {}
- name: virtual_source_2_1_0_1
  id: virtual_source
  parameters:
    stream_id: c
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_sub_xx_0, '1']
- [analog_const_source_x_0_0, '0', blocks_divide_xx_0, '1']
- [analog_const_source_x_1, '0', blocks_stream_mux_0, '1']
- [analog_const_source_x_1_0, '0', blocks_sub_xx_1, '1']
- [analog_const_source_x_1_0_1, '0', blocks_sub_xx_0_0_0, '1']
- [analog_const_source_x_1_1, '0', blocks_sub_xx_0_0, '1']
- [analog_fm_deemph_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [analog_fm_deemph_0, '0', virtual_sink_0, '0']
- [analog_fm_deemph_0_0_0, '0', blocks_multiply_const_vxx_2_0, '0']
- [analog_fm_deemph_0_1, '0', blocks_multiply_const_vxx_2, '0']
- [analog_quadrature_demod_cf_0, '0', analog_fm_deemph_0, '0']
- [analog_quadrature_demod_cf_0_0_0, '0', analog_fm_deemph_0_0_0, '0']
- [analog_quadrature_demod_cf_0_0_0, '0', qtgui_time_sink_x_0_1, '0']
- [analog_quadrature_demod_cf_0_1, '0', analog_fm_deemph_0_1, '0']
- [analog_quadrature_demod_cf_0_1, '0', qtgui_time_sink_x_0_1, '1']
- [analog_rail_ff_0, '0', blocks_delay_0_0_0, '0']
- [analog_rail_ff_0_0_0, '0', virtual_sink_0_0_0, '0']
- [analog_rail_ff_0_0_0_0, '0', blocks_abs_xx_0, '0']
- [analog_rail_ff_0_0_0_0_0, '0', blocks_abs_xx_0_1, '0']
- [analog_rail_ff_0_0_0_1, '0', blocks_abs_xx_0_0, '0']
- [analog_rail_ff_0_0_0_1_0, '0', blocks_abs_xx_0_0_0, '0']
- [analog_rail_ff_0_0_1, '0', virtual_sink_0_0_0_0_0, '0']
- [band_pass_filter_0, '0', analog_quadrature_demod_cf_0, '0']
- [band_pass_filter_0_0, '0', virtual_sink_0_0, '0']
- [blocks_abs_xx_0, '0', blocks_delay_0_1, '0']
- [blocks_abs_xx_0_0, '0', blocks_delay_0_0, '0']
- [blocks_abs_xx_0_0_0, '0', blocks_delay_0_1, '0']
- [blocks_abs_xx_0_1, '0', blocks_delay_0_0, '0']
- [blocks_add_const_vxx_0_0, '0', analog_rail_ff_0_0_0_0, '0']
- [blocks_add_const_vxx_0_0_0, '0', analog_rail_ff_0_0_0_0_0, '0']
- [blocks_add_const_vxx_0_1, '0', analog_rail_ff_0_0_0_1, '0']
- [blocks_add_const_vxx_0_1_1, '0', analog_rail_ff_0_0_0_1_0, '0']
- [blocks_deinterleave_1_0, '0', blocks_null_sink_0_0_1, '0']
- [blocks_deinterleave_1_0, '1', blocks_repeat_0_0_2_0, '0']
- [blocks_deinterleave_1_0_0, '0', blocks_repeat_0_0_2, '0']
- [blocks_deinterleave_1_0_0, '1', blocks_null_sink_0_1, '0']
- [blocks_delay_0_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_delay_0_0_0, '0', blocks_float_to_uchar_0, '0']
- [blocks_delay_0_1, '0', blocks_multiply_const_vxx_1_1, '0']
- [blocks_file_source_0, '0', blocks_uchar_to_float_0, '0']
- [blocks_file_source_1, '0', blocks_short_to_float_0, '0']
- [blocks_float_to_uchar_0, '0', video_sdl_sink_0, '0']
- [blocks_float_to_uchar_0_0, '0', video_sdl_sink_0, '1']
- [blocks_float_to_uchar_0_1, '0', video_sdl_sink_0, '2']
- [blocks_multiply_const_vxx_0, '0', blocks_sub_xx_1, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_float_to_uchar_0_0, '0']
- [blocks_multiply_const_vxx_1_1, '0', blocks_float_to_uchar_0_1, '0']
- [blocks_multiply_const_vxx_2, '0', blocks_sub_xx_0_0, '0']
- [blocks_multiply_const_vxx_2_0, '0', blocks_sub_xx_0_0_0, '0']
- [blocks_repeat_0_0_2, '0', blocks_vector_to_stream_0_2_1_0, '0']
- [blocks_repeat_0_0_2_0, '0', blocks_vector_to_stream_0_2_1, '0']
- [blocks_short_to_float_0, '0', blocks_throttle_0, '0']
- [blocks_short_to_float_0, '0', hilbert_fc_0, '0']
- [blocks_stream_demux_1, '0', blocks_stream_mux_0, '0']
- [blocks_stream_demux_1, '1', blocks_null_sink_1, '0']
- [blocks_stream_demux_1, '2', blocks_stream_mux_0, '2']
- [blocks_stream_to_vector_0_0_1_0_0_0, '0', blocks_deinterleave_1_0, '0']
- [blocks_stream_to_vector_0_0_1_0_0_0_0, '0', blocks_deinterleave_1_0_0, '0']
- [blocks_sub_xx_0, '0', blocks_divide_xx_0, '0']
- [blocks_sub_xx_0_0, '0', blocks_stream_to_vector_0_0_1_0_0_0_0, '0']
- [blocks_sub_xx_0_0_0, '0', blocks_stream_to_vector_0_0_1_0_0_0, '0']
- [blocks_sub_xx_1, '0', analog_rail_ff_0, '0']
- [blocks_throttle_0, '0', blocks_null_sink_0, '0']
- [blocks_uchar_to_float_0, '0', blocks_sub_xx_0, '0']
- [blocks_vector_to_stream_0_2_1, '0', analog_rail_ff_0_0_0, '0']
- [blocks_vector_to_stream_0_2_1, '0', qtgui_time_sink_x_0, '0']
- [blocks_vector_to_stream_0_2_1_0, '0', analog_rail_ff_0_0_1, '0']
- [blocks_vector_to_stream_0_2_1_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_wavfile_source_0, '0', blocks_throttle_0, '0']
- [blocks_wavfile_source_0, '0', hilbert_fc_0, '0']
- [hilbert_fc_0, '0', band_pass_filter_0, '0']
- [hilbert_fc_0, '0', band_pass_filter_0_0, '0']
- [virtual_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [virtual_source_2_1_0, '0', analog_quadrature_demod_cf_0_0_0, '0']
- [virtual_source_2_1_0_0, '0', blocks_add_const_vxx_0_0, '0']
- [virtual_source_2_1_0_0, '0', blocks_add_const_vxx_0_1_1, '0']
- [virtual_source_2_1_0_0_0, '0', blocks_add_const_vxx_0_0_0, '0']
- [virtual_source_2_1_0_0_0, '0', blocks_add_const_vxx_0_1, '0']
- [virtual_source_2_1_0_1, '0', analog_quadrature_demod_cf_0_1, '0']

metadata:
  file_format: 1
