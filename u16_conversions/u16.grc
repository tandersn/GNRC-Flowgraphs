options:
  parameters:
    generate_options: qt_gui
    id: u16
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 40e6
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '256'
    type: float
  states: {}
- name: analog_const_source_x_0_0
  id: analog_const_source_x
  parameters:
    const: '4'
    type: float
  states: {}
- name: analog_rail_ff_0
  id: analog_rail_ff
  parameters:
    hi: '65534'
    lo: '1'
  states: {}
- name: analog_rail_ff_1
  id: analog_rail_ff
  parameters:
    hi: '255'
    lo: '0'
  states: {}
- name: analog_rail_ff_1_0
  id: analog_rail_ff
  parameters:
    hi: '0'
    lo: '-1'
  states: {}
- name: analog_rail_ff_1_1
  id: analog_rail_ff
  parameters:
    hi: '255'
    lo: '0'
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_deinterleave_0
  id: blocks_deinterleave
  parameters:
    type: float
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_divide_xx_0_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /tmp/file.u16
    type: byte
  states: {}
- name: blocks_float_to_uchar_1
  id: blocks_float_to_uchar
  parameters: {}
  states: {}
- name: blocks_float_to_uchar_2
  id: blocks_float_to_uchar
  parameters: {}
  states: {}
- name: blocks_interleave_0
  id: blocks_interleave
  parameters:
    comment: top one low part
    type: byte
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '32768'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '256'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '1024'
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_uchar_to_float_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /laserdisc/captures/spinning/downloaded_samples/drfspider99h50ishPeaks.wav
    repeat: 'True'
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: '66000'
    nconnections: '2'
    type: float
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: U16
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: float
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: U16
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: float
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_divide_xx_0, '1']
- [analog_const_source_x_0_0, '0', blocks_divide_xx_0_0, '1']
- [analog_rail_ff_0, '0', qtgui_number_sink_0, '1']
- [analog_rail_ff_0, '0', virtual_sink_1, '0']
- [analog_rail_ff_1, '0', blocks_float_to_uchar_1, '0']
- [analog_rail_ff_1_0, '0', blocks_multiply_const_vxx_1, '0']
- [analog_rail_ff_1_1, '0', blocks_float_to_uchar_2, '0']
- [blocks_add_const_vxx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_add_xx_0, '0', qtgui_number_sink_0, '0']
- [blocks_deinterleave_0, '0', blocks_add_xx_0, '0']
- [blocks_deinterleave_0, '1', blocks_multiply_const_vxx_0_0, '0']
- [blocks_divide_xx_0, '0', analog_rail_ff_1, '0']
- [blocks_divide_xx_0, '0', analog_rail_ff_1_0, '0']
- [blocks_divide_xx_0_0, '0', analog_rail_ff_1_1, '0']
- [blocks_float_to_uchar_1, '0', blocks_interleave_0, '1']
- [blocks_float_to_uchar_2, '0', blocks_interleave_0, '0']
- [blocks_interleave_0, '0', blocks_file_sink_0, '0']
- [blocks_interleave_0, '0', virtual_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', analog_rail_ff_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_add_xx_0, '1']
- [blocks_multiply_const_vxx_1, '0', blocks_divide_xx_0_0, '0']
- [blocks_throttle_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_uchar_to_float_0_0, '0', blocks_deinterleave_0, '0']
- [blocks_wavfile_source_0, '0', blocks_throttle_0, '0']
- [virtual_source_0, '0', blocks_uchar_to_float_0_0, '0']
- [virtual_source_1, '0', blocks_divide_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.3.0
